options:
  parameters:
    author: Harish
    generate_options: qt_gui
    id: top_block
    output_language: python
    title: 2UE
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: 23.04e6
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_throttle_0_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_throttle_0_0_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: zeromq_rep_sink_0
  id: zeromq_rep_sink
  parameters:
    address: tcp://*:2100
    timeout: '100'
    type: complex
  states: {}
- name: zeromq_rep_sink_1
  id: zeromq_rep_sink
  parameters:
    address: tcp://*:2010
    timeout: '100'
    type: complex
  states: {}
- name: zeromq_rep_sink_2
  id: zeromq_rep_sink
  parameters:
    address: tcp://*:2000
    timeout: '100'
    type: complex
  states: {}
- name: zeromq_req_source_0
  id: zeromq_req_source
  parameters:
    address: tcp://localhost:2011
    timeout: '100'
    type: complex
  states: {}
- name: zeromq_req_source_1
  id: zeromq_req_source
  parameters:
    address: tcp://localhost:2001
    timeout: '100'
    type: complex
  states: {}
- name: zeromq_req_source_3
  id: zeromq_req_source
  parameters:
    address: tcp://localhost:2101
    timeout: '100'
    type: complex
  states: {}

connections:
- [blocks_add_xx_0, '0', blocks_throttle_0, '0']
- [blocks_throttle_0, '0', zeromq_rep_sink_0, '0']
- [blocks_throttle_0_0, '0', zeromq_rep_sink_2, '0']
- [blocks_throttle_0_0_0, '0', zeromq_rep_sink_1, '0']
- [zeromq_req_source_0, '0', blocks_add_xx_0, '1']
- [zeromq_req_source_1, '0', blocks_add_xx_0, '0']
- [zeromq_req_source_3, '0', blocks_throttle_0_0, '0']
- [zeromq_req_source_3, '0', blocks_throttle_0_0_0, '0']

metadata:
  file_format: 1
